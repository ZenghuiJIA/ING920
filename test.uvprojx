# Keil uVision project test.uvprojx, settings and files
target ing920 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00004000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ing920 +hex
  AfterMake: fromelf.exe --bin -o ing920.bin ./output/ing920.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c include: .\FWlib\ing920;.\FWlib;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./src/: main.c timer_delay.c SEGGER_RTT.c gpio.c SEGGER_RTT_printf.c misc.c uart.c test.c timer.c PWM.c spi_master.c
  group StartUP
    ./src/: startup_ing920.s
  group FWlib
    ./FWlib/: peripheral_gpio.c peripheral_sysctrl.c peripheral_pinctrl.c peripheral_uart.c peripheral_timer.c peripheral_dma.c peripheral_pwm.c peripheral_ssp.c
software components: CMSIS:CORE 5.6.0
