# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91600 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x2200000) IRAM(0x20000000-0x20008000)
  output: test +hex
  AfterMake: fromelf.exe --bin -o test.bin ./output/test.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../../../../Program/ING_SDK/sdk/bundles/typical/inc;../../../../Program/ING_SDK/sdk/bundles/typical/inc/os;../../../../Program/ING_SDK/sdk/src/BSP;../../../../Program/ING_SDK/sdk/src/FWlib;../../../../Program/ING_SDK/sdk/src/StartUP/ing916;../../../../Program/ING_SDK/sdk/src/Tools;../../../../Program/ING_SDK/sdk/src
  library: MicroLIB
  memory RVCT4: ROM 33726464 size 352256
  memory RVCT9: RAM 536892448 size 11232
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../../../Program/ING_SDK/sdk/bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../../../../Program/ING_SDK/sdk/src/BSP/: eflash.c
  group FWlib
    ../../../../Program/ING_SDK/sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    ../../../../Program/ING_SDK/sdk/src/Tools/: trace.c
